* Example test circuit with a diode, BJT, and MOSFET
D1 N001 N002 D
Q1 N003 N004 N005 NPN
Q2 N014 N015 N016 PNP
M1 N006 N007 N008 N009 NMOS
M2 N010 N011 N012 N013 PMOS
R1 N020 N021 10 1 0.1
C1 N022 N023 8.85e-12 1e-4 1e-6
L1 N024 N025 2e-3
ZD1 N026 N027 5.6 1e-12
V1 N028 0 ac 10 1000
V2 N029 0 dc 5
OP1 V+ V- Vout 1e5 15
I1 N030 N031 0.002
U1 N1 N2 N3 100000 1000000 100
